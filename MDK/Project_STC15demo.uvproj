# Keil uVision project Project_STC15demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project_STC15demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\App
  group Source Group 1
    ./: STARTUP.A51
    ../User/: main.c public.c
    ../App/: LED.c Sys_init.c Timer0.c
